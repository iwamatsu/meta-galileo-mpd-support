IMAGE_INSTALL += "mpd"
